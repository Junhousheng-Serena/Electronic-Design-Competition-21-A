# Keil uVision project THDMeasurementB.uvprojx, settings and files
target THDMeasurementB (6210000::V6.21::ARMCLANG)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.2
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: THDMeasurementB +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H750xx,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/USART+Interruption;../Drivers/BSP/oledproject_ssd1306
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: THDMeasurementB\THDMeasurementB.sct
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group BSP
    ../Drivers/BSP/USART+Interruption/: valuepack.c valuepack.h
    ../Drivers/BSP/oledproject_ssd1306/: font.c font.h oled.c oled.h
software components: CMSIS:CORE 6.1.1, CMSIS:DSP 1.15.0, Compiler:I/O:STDERR 1.2.0
